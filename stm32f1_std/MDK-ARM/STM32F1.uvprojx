# Keil uVision project STM32F1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,USE_FULL_ASSERT
  c include: ..\User\Inc;..\M_BSP\M_CORE;..\M_BSP\M_MEMORY;..\M_BSP\M_SUP;..\M_BSP\M_PORT;..\Board_Bsp;..\M_BSP\M_FLASH\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xb000
  group Main
    ../User/Src/: main.c stm32f1xx_it.c
  group M_BSP/Core
    ../M_BSP/M_CORE/: m_scheduler.c m_timer.c
  group M_BSP/Memory
    ../M_BSP/M_MEMORY/: m_alloc.c
  group M_BSP/Flash/Src
    ../M_BSP/M_FLASH/src/: ef_env.c ef_utils.c easyflash.c
  group M_BSP/Flash/Port
    ../M_BSP/M_FLASH/port/: ef_port.c
  group M_BSP/Sup
    ../M_BSP/M_SUP/: printf.c
  group M_BSP/Port
    ../M_BSP/M_PORT/: m_port.c
  group Board
    ../Board_Bsp/: Board_init.c Board_Uart.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
